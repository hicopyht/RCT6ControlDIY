# Keil uVision project RCT6BaseControl.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RCT6ControlDIY +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\API;..\CM3;..\Other_Device_Driver;..\STM32F10x_StdPeriph_Driver\inc;..\User\sysinit;..\User
  asm include: ..\API;..\CM3;..\Other_Device_Driver;..\STM32F10x_StdPeriph_Driver\inc;..\User\sysinit
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: Configuration.c main.c var.c Function.c motor.c parameter.c pid.c LowPassFilter2p.c
  group Sysinit
    ../User/sysinit/: RCC_Configuration.c DMA_Configuration.c GPIO_Configuration.c NVIC_Configuration.c SysTick_Configuration.c USART_Configuration.c EXTI_Configuration.c TIM_Configuration.c ADC_Configuration.c I2C_Configuration.c SPI_Configuration.c
  group IRQHandler
    ../User/IRQHandler/: DMA_IRQHandler.c SysTick_Handler.c USART1_IRQHandler.c EXTI_IRQHandler.c TIM8_IRQHandler.c USART2_IRQHandler.c
  group Other_Device_Driver
    ../Other_Device_Driver/: MPU6000.c
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_i2c.c stm32f10x_bkp.c stm32f10x_pwr.c
  group StartUp
    ../CM3/startup/arm/: startup_stm32f10x_hd.s
  group CM3
    ../CM3/: core_cm3.c system_stm32f10x.c
